options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: zmq_stream
    output_language: python
  states: {}

blocks:
- name: ip
  id: variable
  parameters:
    value: '"192.168.0.210"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 125e6/2**16
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 0,0
    size: '16384'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0
    size: '16384'
    srate: '1'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://"+ip+":9901"'
    timeout: '200'
    type: short
  states: {}
- name: zeromq_sub_source_0_0_0_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://"+ip+":9902"'
    timeout: '200'
    type: short
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [zeromq_sub_source_0_0_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [zeromq_sub_source_0_0_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
