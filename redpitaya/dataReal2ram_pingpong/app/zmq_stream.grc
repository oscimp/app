options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: zmq_stream
    output_language: python
  states: {}

blocks:
- name: ip
  id: variable
  parameters:
    value: '"192.168.0.200"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 125e6/2**14
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 0,0
    name: '"data_to_ram"'
    size: '16384'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0
    name: '"data_to_ram_pingpong"'
    size: '16384'
    srate: samp_rate
    type: float
  states: {}
- name: zeromq_sub_source_0_0_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://"+ip+":9901"'
    timeout: '200'
    type: short
  states: {}
- name: zeromq_sub_source_0_0_0_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://"+ip+":9902"'
    timeout: '200'
    type: short
  states: {}

connections:
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [zeromq_sub_source_0_0_0, '0', blocks_short_to_float_0, '0']
- [zeromq_sub_source_0_0_0_0, '0', blocks_short_to_float_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
